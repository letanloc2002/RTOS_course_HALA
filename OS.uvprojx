# Keil uVision project OS.uvprojx, settings and files
target OS (6140000::V6.14::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group App
    ./: main.c
  group osKernel
    ./: osKernel.c oskernel.h osKernel.s
software components: CMSIS:CORE 6.1.0, Device:CubeMX 1.0.0
